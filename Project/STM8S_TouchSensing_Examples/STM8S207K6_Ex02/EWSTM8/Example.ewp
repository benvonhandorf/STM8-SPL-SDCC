# IAR project Example.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207K6 STM8S207K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\..\libraries\STM8S_TouchSensing_Driver\inc; ..\..\..\..\libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Example.srec
  ILINK.IlinkOutputFile: Example.elf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Source Files
    ../src/: main.c stm8s_it.c
  group STM8S_TouchSensing_Driver
    ../../../../Libraries/STM8S_TouchSensing_Driver/src/: stm8_tsl_api.c stm8_tsl_multichannelkey.c stm8_tsl_rc_acquisition.c stm8_tsl_services.c stm8_tsl_singlechannelkey.c stm8_tsl_timebase.c
